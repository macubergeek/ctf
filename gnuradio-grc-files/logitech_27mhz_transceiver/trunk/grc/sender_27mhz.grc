<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>27.12e6+25e3</value></param>
<param><key>min</key><value>27.12e6-25e3</value></param>
<param><key>max</key><value>27.12e6+25e3</value></param>
<param><key>num_steps</key><value>1</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>logitech_27mhz_transceiver_key_src_b</key>
<param><key>id</key><value>logitech_27mhz_transceiver_key_src_b_0</value></param>
</block>
<block>
<key>blks2_gmsk_mod</key>
<param><key>id</key><value>blks2_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>54</value></param>
<param><key>bt</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>5e3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>logitech_27mhz_transceiver_packet_encoder</key>
<param><key>id</key><value>logitech_27mhz_transceiver_packet_encoder_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>kbid</key><value>db4</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>usrp_simple_sink_x</key>
<param><key>id</key><value>usrp_simple_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>which</key><value>0</value></param>
<param><key>interpolation</key><value>500</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>side</key><value>A</value></param>
<param><key>transmit</key><value>tx_enb</value></param>
</block>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>usrp_simple_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_gmsk_mod_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logitech_27mhz_transceiver_key_src_b_0</source_block_id><sink_block_id>logitech_27mhz_transceiver_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logitech_27mhz_transceiver_packet_encoder_0</source_block_id><sink_block_id>blks2_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
